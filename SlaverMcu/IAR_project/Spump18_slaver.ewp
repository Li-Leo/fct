# IAR project Spump18_slaver.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR5989 MSP430FR5989
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: _DEBUG
  ICC430.newCCIncludePaths: ..\Source; ..\Source\App; ..\Source\Kernel; ..\Source\Driver
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: msp430fr5989.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.ADefines: NDEBUG
configuration UT (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: _DEBUG; UNIT_TEST
  group Link
    ./: msp430fr5989.xcl
  group Source
    ../Source/: Common.c Common.h main.c msp430fr5989.h TypeDefine.h version.c version.h
  group Source/app
    ../Source/App/: AppAlarm.c AppAlarm.h AppEngineerMode.c AppEngineerMode.h AppEventHandle.c AppEventHandle.h AppMonitor.c AppMonitor.h AppSysState.c AppSysState.h Init.c Init.h
  group Source/driver
    ../Source/Driver/: DrvAdc.c DrvAdc.h DrvBeep.c DrvBeep.h DrvClk.c DrvClk.h DrvEncoder.c DrvEncoder.h DrvFram.c DrvFram.h DrvHall.c DrvHall.h DrvMotor.c DrvMotor.h DrvPort.c DrvPort.h DrvPower.c DrvPower.h DrvSpi.c DrvSpi.h DrvTimer.c DrvTimer.h DrvUart.c DrvUart.h
  group Source/kernel
    ../Source/Kernel/: CtlAdc.c CtlAdc.h CtlAlarm.c CtlAlarm.h CtlComm.c CtlComm.h CtlData.c CtlData.h CtlDelivery.c CtlDelivery.h CtlEvent.c CtlEvent.h CtlInterrupt.c CtlInterrupt.h CtlMotor.c CtlMotor.h CtlPower.c CtlPower.h CtlSpiComm.c CtlSpiComm.h CtlTime.c CtlTime.h CtlTimer.c CtlTimer.h
  group UT
    ../UT/: test_battery.c test_low_power.c test_pulse.c test_timer.c unit_test.c
